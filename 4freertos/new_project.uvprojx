# Keil uVision project new_project.uvprojx, settings and files
target f103 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: new_project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\freertos
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./: main.c
  group doc
    ./: readme.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
